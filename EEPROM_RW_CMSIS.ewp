# IAR project EEPROM_RW_CMSIS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RE ST STM32F303RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303xE
  ICCARM.CCIncludePath2: CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: delay.c delay.h m24m01_EEPROM.c m24m01_EEPROM.h main.c mcuInit.c mcuInit.h
  group CMSIS
    $EW_DIR$/arm/inc/c/: cmsis_iar.h DLib_Config_Normal.h DLib_Defaults.h DLib_Product.h DLib_Product_stdlib.h iccarm_builtin.h stdbool.h stdint.h stdlib.h ycheck.h ysizet.h yvals.h
    CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f303xe.s stm32f303xe.h system_stm32f3xx.c system_stm32f3xx.h
