<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EEPROM_RW_CMSIS.ewp</path>
    </project>
    <batchBuild />
</workspace>
